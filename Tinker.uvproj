# Keil uVision project Tinker.uvproj, settings and files
target mbed NXP LPC1768 (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Tinker
  AfterMake: fromelf --bin -o build\Tinker_LPC1768.bin build\Tinker.axf
  c flags: Optim=1
  c define: TARGET_LPC1768,  TARGET_M3,  TARGET_CORTEX_M,  TARGET_NXP,  TARGET_LPC176X,  TARGET_MBED_LPC1768,  TOOLCHAIN_ARM_STD,  TOOLCHAIN_ARM,  __CORTEX_M3,  ARM_MATH_CM3,  MBED_BUILD_TIMESTAMP=1422194821.59,  __MBED__=1,  __ASSERT_MSG,
  c misc: --gnu --no_rtti
  c include: .;  cmdline;  EthernetInterface;  EthernetInterface/Socket;  EthernetInterface/lwip;  EthernetInterface/lwip/core;  EthernetInterface/lwip/core/ipv4;  EthernetInterface/lwip/core/snmp;  EthernetInterface/lwip/api;  EthernetInterface/lwip/netif;  EthernetInterface/lwip/netif/ppp;  EthernetInterface/lwip/include;  EthernetInterface/lwip/include/ipv4;  EthernetInterface/lwip/include/ipv4/lwip;  EthernetInterface/lwip/include/lwip;  EthernetInterface/lwip/include/netif;  EthernetInterface/lwip-sys;  EthernetInterface/lwip-sys/arch;  EthernetInterface/lwip-eth;  EthernetInterface/lwip-eth/arch;  EthernetInterface/lwip-eth/arch/TARGET_NXP;  mbed-rtos;  mbed-rtos/rtos;  mbed-rtos/rtx;  mbed-rtos/rtx/TARGET_CORTEX_M;  mbed-rtos/rtx/TARGET_CORTEX_M/TARGET_M3;  mbed-rtos/rtx/TARGET_CORTEX_M/TARGET_M3/TOOLCHAIN_ARM;  mbed;  mbed/TARGET_LPC1768;  mbed/TARGET_LPC1768/TOOLCHAIN_ARM_STD;  mbed/TARGET_LPC1768/TARGET_NXP;  mbed/TARGET_LPC1768/TARGET_NXP/TARGET_LPC176X;  mbed/TARGET_LPC1768/TARGET_NXP/TARGET_LPC176X/TARGET_MBED_LPC1768
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  scatter file: mbed/TARGET_LPC1768/TOOLCHAIN_ARM_STD/LPC1768.sct
  link misc: mbed/TARGET_LPC1768/TOOLCHAIN_ARM_STD/retarget.o
            
              mbed/TARGET_LPC1768/TOOLCHAIN_ARM_STD/system_LPC17xx.o
            
              mbed/TARGET_LPC1768/TOOLCHAIN_ARM_STD/board.o
            
              mbed/TARGET_LPC1768/TOOLCHAIN_ARM_STD/cmsis_nvic.o
            
              mbed/TARGET_LPC1768/TOOLCHAIN_ARM_STD/startup_LPC17xx.o
            
              mbed/TARGET_LPC1768/TOOLCHAIN_ARM_STD/sys.o
            
              mbed/TARGET_LPC1768/TOOLCHAIN_ARM_STD/mbed.ar
  group src
    mbed-rtos/rtx/TARGET_CORTEX_M/TARGET_M3/TOOLCHAIN_ARM/: SVC_Table.s HAL_CM3.c
    cmdline/: cmdline.c
    EthernetInterface/lwip/core/: mem.c tcp.c netif.c tcp_in.c dhcp.c memp.c tcp_out.c udp.c def.c stats.c dns.c raw.c timers.c pbuf.c init.c
    EthernetInterface/lwip/core/ipv4/: igmp.c ip_frag.c autoip.c inet.c icmp.c ip_addr.c inet_chksum.c ip.c
    EthernetInterface/lwip/core/snmp/: msg_in.c asn1_enc.c mib_structs.c asn1_dec.c mib2.c msg_out.c
    EthernetInterface/lwip/api/: netifapi.c sockets.c netbuf.c netdb.c api_lib.c err.c api_msg.c tcpip.c
    EthernetInterface/lwip/netif/: etharp.c slipif.c ethernetif.c
    EthernetInterface/lwip/netif/ppp/: auth.c pap.c randm.c md5.c lcp.c magic.c chap.c ppp.c ppp_oe.c ipcp.c vj.c fsm.c chpms.c
    EthernetInterface/lwip-sys/arch/: sys_arch.c checksum.c memcpy.c
    EthernetInterface/lwip-eth/arch/TARGET_NXP/: lpc17_emac.c lpc_phy_dp83848.c
    mbed-rtos/rtx/TARGET_CORTEX_M/: rt_Semaphore.c rt_Event.c rt_List.c rt_Mutex.c HAL_CM.c rt_Task.c rt_CMSIS.c rt_System.c rt_Time.c rt_MemBox.c rt_Robin.c RTX_Conf_CM.c rt_Mailbox.c
    ./: main.cpp Motor.cpp
    EthernetInterface/: EthernetInterface.cpp
    EthernetInterface/Socket/: Endpoint.cpp TCPSocketServer.cpp UDPSocket.cpp Socket.cpp TCPSocketConnection.cpp
    mbed-rtos/rtos/: Thread.cpp Semaphore.cpp Mutex.cpp RtosTimer.cpp
